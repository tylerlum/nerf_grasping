Commit message: fixed grasping pipeline in notebook, starting to eval generated grasps

File: assets/objects/urdf/ball.urdf (robot description, URDF)
Before this commit: robot ball, 1 links, 0 joints
Links:
- link ball: mass .25 -> .1; geometry collision sphere radius=.01; visual sphere radius=.01
